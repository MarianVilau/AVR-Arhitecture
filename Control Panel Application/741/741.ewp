# IAR project 741.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: DLib_Config_Normal.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m324pb ATmega324PB
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  group (top)
    ./: adc.c adc.h btn.c btn.h cpanel.c cpanel.h gpio.c gpio.h led.c led.h main.c pins.c pins.h pwm.c pwm.h scheduler.c scheduler.h scheduler_cfg.c sheduler_cfg.h sos.c sos.h timmer.c timmer.h uart_init.c uart_init.h uart_receive.c uart_receive.h uart_send.c uart_send.h
